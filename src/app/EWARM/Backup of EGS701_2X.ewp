# IAR project Backup of EGS701_2X.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EYE_MODEM; EYE_EGS701; TTS_MODEM
  ICCARM.CCIncludePath2: ..\src\user; ..\src\driver; ..\src\user\modem\tcpnet; ..\src\user\modem\app; ..\src\user\CAN; ..\src\user\Module_IC_Card; ..\src\user\printer; ..\src\user\Record; ..\src\user\vdr; ..\..\..\lib\CMSIS\V1.0.0\CM3\CoreSupport; ..\..\..\lib\CMSIS\V1.0.0\CM3\DeviceSupport\ST\STM32F2xx; ..\..\..\lib\CMSIS\V1.0.0\CM3\DeviceSupport\ST\STM32F2xx\startup\iar; ..\..\..\lib\STM32F2xx_StdPeriph_Driver\V1.0.0\src; ..\..\..\lib\STM32F2xx_StdPeriph_Driver\V1.0.0\inc; ..\..\..\lib\USB\FAT_FS\src\option; ..\..\..\lib\USB\FAT_FS\src; ..\..\..\\lib\USB\FAT_FS\inc; ..\..\..\lib\USB\USB_APP\src; ..\..\..\lib\USB\USB_APP\inc; ..\..\..\lib\USB\USB_Lib\Driver\src; ..\..\..\lib\USB\USB_Lib\Driver\inc; ..\..\..\lib\USB\USB_Lib\Library\Core\src; ..\..\..\lib\USB\USB_Lib\Library\Core\inc; ..\..\..\lib\USB\USB_Lib\Library\Class\MSC\src; ..\..\..\lib\USB\USB_Lib\Library\Class\MSC\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HB-EGS701GB_BZ-V1.11.06.1.bin
  ILINK.IlinkOutputFile: EGS701_2X.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../lib/CMSIS/V1.0.0/CM3/CoreSupport/: core_cm3.c
    ../../../lib/CMSIS/V1.0.0/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../../../lib/CMSIS/V1.0.0/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Driver
    ../src/driver/: Adc.c Camera_Driver.c Can.c CAN1_Driver.c CAN2_Driver.c comm.c Driver_USART6.c E2prom_25LC320A.c ErrorAndTime.c fm25c160.c GPIOControl.c Gps_Driver.c I2C.c Io.c lcd_driver.C logprintf.c Pulse_Driver.c rtc.c spi.c spi_flash.c stm32f2xx_it.c TTSDevDrv.c Usart1.c Usart2.c Usart3.c Usart_drive.c
    ../src/user/: Subpackage.c
  group STM32F2xx_StdPeriph
    ../../../lib/STM32F2xx_StdPeriph_Driver/V1.0.0/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group USB/FAT_FS
    ../../../lib/USB/FAT_FS/src/option/: ccsbcs.c
    ../../../lib/USB/FAT_FS/src/: fattime.c ff.c
  group USB/USB_APP
    ../../../lib/USB/USB_APP/src/: usb_app.c usb_bsp.c usbh_usr.c
  group USB/USB_LIB/USB_CLASS
    ../../../lib/USB/USB_Lib/Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB/USB_LIB/USB_CORE
    ../../../lib/USB/USB_Lib/Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB/USB_LIB/USB_DRIVER
    ../../../lib/USB/USB_Lib/Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group User
    ../src/user/: adc_key.c adc_tran_voltag.c AreaManage.c Blind.c Bma250.c Camera_App.c Card.c Carload.c Corner.c Crc16.c crypt.c DeepPlow.c doubtpoint.c downloadGB2313.c E2ParamApp.c EepromPram.c EeyeLib.c EIExpand.c ESpin.c Gdi.c Gnss_app.c Gps_App.c Gyro.c HeartBeat.c JointechOiL_Protocol.c JTReport.c Lcd.C LoadControllerUpdata.c log_power.c LzmSys.c main.c Media.c MediaSearch.c Menu.c Message.c MileMeter.c mmc_sd.c Module_Sensor_MixerRotate.c MuckDump.c NaviLcd.c OilControl.c OilWearCalib.c OpenAccount.c other.c Phone.c PhoneBook.c Photo.c Polygon.c position.c Public.c Pulse_App.c queue.c RadioProtocol.c Register.c Report.c route.c Sleep.c SleepDeep.c SpeedLog.c speedmonitor.c Spin.c StatusAlarm.c SystemInit.c SysTickApp.c TaskMenu.c taskschedule.c temperature.c test.c timer.c tireddrive.c TTSDevApp.c turnspeed.c VDR_Coefficient.c
  group User/CAN
    ../src/user/CAN/: CAN1_APP.c CAN2_APP.c Module_CAN.c
  group User/IC
    ../src/user/Module_IC_Card/: ICCARD_E2.c ICCARD_M3.c Module_IC_Card.c Module_IC_Card_EEYE.c Module_IC_Card_JTB.c
  group User/modem/app
    ../src/user/modem/app/: modem_app_com.c modem_app_first.c modem_app_other.c modem_app_second.c
  group User/modem/tcpnet
    ../src/user/modem/tcpnet/: modem_api.c modem_bsp.c modem_core.c modem_debug.c modem_lib.c modem_port.c modem_state.c modem_uart.c
  group User/Printer
    ../src/user/printer/: b_queue.c font.c printer.c printer_test.c ptr_stepmotor_ctrl.c ptr_temperature.c ptr_timer.c
    ../user/printer/: b_queue.h font.h font_lib.h printer.h ptr_stepmotor_ctrl.h ptr_temperature.h ptr_timer.h
  group User/Record
    ../src/user/Record/: G711.c I2S_Record.c Record_Task.c wav.c
  group User/vdr
    ../src/user/vdr/: vdr.c vdr_get.c vdr_mem.c vdr_pub.c vdr_set.c vdr_test.c vdr_usb.c
